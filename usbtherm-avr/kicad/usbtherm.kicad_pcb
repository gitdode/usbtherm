# Repository gitdode/usbtherm

File README.md:

# USBTherm
Simple micro controller based USB thermometer with Linux kernel driver module and simple Java desktop app

This repository contains four projects:

* usbtherm-avr - USB thermometer based on an AVR micro controller and the https://github.com/obdev/v-usb firmware-only USB implementation
* usbtherm-kicad - KiCad project including schematic and PCB layout and a board at https://oshpark.com/shared_projects/ln73noyo
* usbtherm-linux - Basic but complete Linux kernel USB character device driver module
* usbtherm-libusb - Minimal interface to the device using libusb (much simpler and portable alternative to the Linux driver)
* usbtherm-ui - Simple Java desktop application displaying the temperature

A detailed description of the project can be found at http://luniks.net/usbtherm.jsp

## KiCad design usbtherm-avr/kicad/usbtherm.kicad_pcb

Parts:
C1, C2: 22pF; C_Disc_D3_P2.5
C3: 100nF; C_Disc_D6_P5
C4: 10uF; C_Radial_D5_L6_P2.5
D1, D2: 3.6V; Resistor_Horizontal_RM7mm
D3: Blue; LED-3MM
D4: Red; LED-3MM
IC1: ATMEGA328-P; DIP-28_W7.62mm
P1: USB_A_PLUG
Q1: TMP36; TO-92_Inline_Wide
R1, R2: 68; Resistor_Horizontal_RM10mm
R3: 1.5K; Resistor_Horizontal_RM10mm
R4: 1M; Resistor_Horizontal_RM10mm
R5, R6: 220; Resistor_Horizontal_RM10mm
Y1: 12 MHz; Crystal_HC49-U_Vertical

Connections:
GND: C1.2, C2.2, C3.2, C4.2, D1.2 (A), D2.2 (A), D3.1 (K), D4.1 (K), IC1.8 (GND), IC1.22 (GND), P1.4, Q1.3 (GND), R4.2
unnamed: C1.1, IC1.10 ((PCINT7/XTAL2/TOSC2)PB7), Y1.1
unnamed: C2.1, IC1.9 ((PCINT6/XTAL1/TOSC1)PB6), Y1.2
unnamed: C3.1, C4.1, IC1.7 (VCC), IC1.20 (AVCC), P1.1, Q1.1 (+Vs), R3.1, R6.1
unnamed: D1.1 (K), P1.2, R1.1, R3.2
unnamed: D2.1 (K), P1.3, R2.1, R4.1
unnamed: D3.2 (A), R5.1
unnamed: D4.2 (A), R6.2
unnamed: IC1.4 ((PCINT18/INT0)PD2), R2.2
unnamed: IC1.6 ((PCINT20/XCK/T0)PD4), R1.2
unnamed: IC1.14 ((PCINT0/CLKO/ICP1)PB0), R5.2
unnamed: IC1.23 ((PCINT8/ADC0)PC0), Q1.2 (Vout)

Board: 2 copper layers, 27.9 x 67.3 mm, 18 parts (0 on the bottom side), 12 nets.

## Commit log

2016-05-28 removed requests.h since it is not needed for now
2016-05-28 initial commit of avr project
2016-05-28 added USART module, initial implementation of measuring temperature with a TMP36
2016-05-28 updated .gitignore
2016-05-29 added usb_driver probe and disconnect
2016-05-29 using usb_class_driver and module_usb_driver, added "opening" and reading something from the USB device
2016-05-29 just some small changes
2016-05-31 implemented reading from the device
2016-06-03 simplified makefile, added LED that flashes when the temperature is measured
2016-06-04 added initial simple Java Swing UI
2016-06-04 added unit tests
2016-06-04 removed property "swing.aatext" which was already removed in 1.6
2016-06-04 create the device file with permissions 644 so it is readable by everyone
2016-06-04 put test dependencies to scope test, moved temperature format to constant
2016-06-04 fixed function device_read; don't read more than there is (NUL character)
2016-06-06 use custom private vendor and product id actually used by the device, read temperature value from device
2016-06-06 run with 16 MHz, changed device name, implemented status request to read temperature value, small improvements
2016-06-06 divide temperature value by 10
2016-06-07 some cleanup
2016-06-07 adjusted tests
2016-06-07 added a simple startup script
2016-06-07 comments
2016-06-08 added a simple makefile
2016-06-08 removed unnecessary includes
2016-06-08 check return value of usb_register_dev
2016-06-08 added comment on install rule
2016-06-08 make device node writeable for everyone, formatting
2016-06-09 commented debug logging
2016-06-12 added initial PCB design with KiCad
2016-06-12 replaced USB connector with plug, created footprint for it, added board edges, autorouted with FreeRouting, fixed offset of 3D model of resistors
2016-06-12 set PIN_LED to PB0 according to schematic
2016-06-14 fixed 2 DRC warnings, added ground plane
2016-06-14 modified the silk screen of the USB plug to not extend the board edges and changed the oval drills for the shield pins to circular so it looks okay at OSHPark
2016-06-14 added short description
2016-06-14 gitignore files created during build, added short description
2016-06-14 set avr-eclipse MCU setting to 12 MHz
2016-06-14 Add files via upload
    added LICENSE back
2016-06-14 Create README.md
    added initial README
2016-06-14 Update README.md
    updated text
2016-06-14 Update README.md
    added link to the V-USB github repo
2016-06-14 added GPLv3 text
2016-06-14 updated text
2016-06-15 fixed function device_read
2016-06-15 added comment on executable-jar-archetype
2016-06-15 added comment on TMP36
2016-06-15 moved the KiCad project to its own project
2016-06-22 better wording
2016-06-24 added comment
2016-06-29 removed link to broken PCB
2016-06-30 added link to board with fixed layout
2016-06-30 fixed wrong USB plug pin layout, other minor layout improvements, removed redundant include
2016-06-30 added link to project page
2016-07-01 just a cosmetic change
2016-11-02 fixed URL to project homepage
2017-05-01 added include for asm/uaccess.h for copy_to_user
2017-05-01 allocate URB transfer buffer in kernel memory instead of using on-stack buffer to avoid error with "transfer buffer not dma capable" since Kernel 4.9
2017-05-01 compile with -Wall
2017-05-09 fixed compiler error in Eclipse Neon 3
2017-06-15 updated URL
2017-12-02 include linux/uaccess.h instead of asm/uaccess.h
2018-10-21 use strlcpy to avoid -Wstringop-truncation
2019-12-31 moved to Bitbucket
2019-12-31 fix links
2020-01-04 add project for libusb interface
2020-01-04 include usbtherm-libusb
2020-01-04 log error when transfer failed
2020-01-04 add support for libusb interface
2020-01-04 remove local files from repo
2020-01-04 improve javadoc, add license
2020-01-05 add support for libusb, fix test, update versions of dependencies
2020-01-05 include linux binary
2020-01-05 include executable JAR and shell script
2020-01-05 remove binaries from version control
2021-02-13 README.md edited online with Bitbucket
2021-06-06 update, include .travis.yml in usbtherm-ui
2021-06-06 move .travis.yml to root and cd to usbtherm-ui
2021-06-06 ignore test with local dependencies for now
2021-06-06 try another approach in .travis.yml
2021-06-06 see if the Linux driver can be built as well :-)
2022-04-20 just some formatting
2023-01-09 add binaries for USBTherm
2023-01-22 increase usb transfer buffer to 16 bytes for temperature and humidity
2023-02-10 add NetBeans project
2023-02-10 allocate Kernel memory just before it is needed
2023-03-01 update to NetBeans 17
2023-03-20 use symlinks to Kernel headers
2023-03-20 cleanup project
2023-10-07 ignore target, update NetBeans project configuration
2024-08-24 Fix build with recent Kernel 6.10
2025-07-04 Add MODULE_DESCRIPTION, reformat
2025-07-04 Add MODULE_DESCRIPTION, reformat (#2)

Notices in the files:
usbtherm-avr/kicad/usbtherm.kicad_pcb:
License: GPL
